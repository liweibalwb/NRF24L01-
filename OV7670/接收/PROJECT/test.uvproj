# Keil uVision project test.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\malloc;..\SYSTEM\util;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BUZZER;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\SRAM;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\SD;..\HARDWARE\VS10XX;..\HARDWARE\U_HOST;..\HARDWARE\RTC;..\HARDWARE\OV7670;..\HARDWARE\SCCB;..\FATFS\src;..\APPLICATION\MP3;..\TEXT;..\PIC;..\HARDWARE\TIMER;..\HARDWARE\NRF24L01
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c main.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/malloc/: mem_malloc.c mem_malloc.h
    ../SYSTEM/util/: util.c util.h
  group FWLIB
    ../FWLIB/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/BUZZER/: buzzer.c buzzer.h
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h myiic.c myiic.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/FLASH/: flash.c flash.h
    ../HARDWARE/SRAM/: sram.c sram.h
    ../HARDWARE/LCD/: FONT.H R61509V.c TFT.h
    ../HARDWARE/TOUCH/: touch.c touch.h
    ../HARDWARE/SD/: sdio_sd.c sdio_sd.h
    ../HARDWARE/U_HOST/: ch375.c ch375.h CH375HFM.LIB CH375HFM.H
    ../HARDWARE/VS10XX/: flac.h SPEC_REW.H VS10XX.c VS10XX.h
    ../HARDWARE/RTC/: rtc.c rtc.h
    ../HARDWARE/OV7670/: OV7670.c OV7670.h
    ../HARDWARE/SCCB/: SCCB.c SCCB.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/NRF24L01/: 24l01.c 24l01.h
  group FATFS
    ../FATFS/src/: diskio.c explorer.c ff.c mycc936.c
  group APPLICATION
    ../APPLICATION/MP3/: mp3player.c mp3player.h
  group TEXT
    ../TEXT/: display_hazi.c display_hazi.h fontupd.c fontupd.h
  group PIC
    ../PIC/: bmp.c bmp.h show_picture.c show_picture.h tjpgd.c tjpgd.h
